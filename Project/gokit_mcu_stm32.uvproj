# Keil uVision project gokit_mcu_stm32.uvproj, settings and files
target gokit_stm32 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: gokit_mcu_stm32 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,MOTOR_16
  c misc: --c99
  c include: ..\Lib\STM32F10x_StdPeriph_Driver\inc;..\Lib\CMSIS\CM3\CoreSupport;..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\User;..\Hal;..\Protocol;..\Hal\Hal_PCF8563;..\Hal\HAl_GPIO;..\Hal\Hal_GUANGOU;..\Hal\Hal_Step_otor
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Lib
    ../Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: stm32f10x_it.c main.c delay.c
  group Hal
    ../Hal/Hal_key/: hal_key.c
    ../Hal/Hal_led/: Hal_led.c
    ../Hal/hal_motor/: hal_motor.c
    ../Hal/Hal_rgb_led/: hal_rgb_led.c
    ../Hal/hal_temp_hum/: hal_temp_hum.c
    ../Hal/Hal_Usart/: hal_uart.c
    ../Hal/Hal_infrared/: hal_infrared.c
    ../Hal/HAl_GPIO/: GPIO.C
    ../Hal/Hal_PCF8563/: SW_PCF8563.C
    ../Hal/Hal_luoyao/: luoyao.c
    ../Hal/Hal_GUANGOU/: Hal_GUANGOU.c
    ../Hal/Hal_Step_otor/: Hal_Step_otor.c
  group Protocol
    ../Protocol/: Protocol.c ringbuffer.c
